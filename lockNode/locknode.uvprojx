# Keil uVision project locknode.uvprojx, settings and files
target locknode (ARM-ADS)
  device: STM32L051C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.1
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: locknode +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L051xx,USE_STM32L0XX_NUCLEO
  c include: .\app\inc;.\drivers\inc;.\library\inc;.\library\cmsis;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ./library/CMSIS/: startup_stm32l051xx.s
  group User
    ./user/: main.c stm32l0xx_it.c temp.c process.c lora_com.c
    ./library/CMSIS/: system_stm32l0xx.c
  group Library
    ./library/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_pwr.c stm32l0xx_hal_rcc.c stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c
  group APP
    ./app/src/: schd.c GlobalVar.c
  group Drivers
    ./drivers/src/: finger.c delay.c led.c SPI.c SX1276.C usart.c lowpower.c rtc_alarm.c
    ./user/: lock.c
    ./library/Src/: stm32l0xx_hal_rcc_ex.c
